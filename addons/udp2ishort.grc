options:
  parameters:
    author: knegge
    generate_options: no_gui
    id: udp2ishort
    output_language: python
    run_options: run
    title: Read UDP from a SatNOGS flowgraph
  states: {}

blocks:
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/stdout
    type: short
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '16768'
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 0.0.0.0
    port: '57356'
    psize: '1472'
    type: complex
    vlen: '1'
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [blocks_udp_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
